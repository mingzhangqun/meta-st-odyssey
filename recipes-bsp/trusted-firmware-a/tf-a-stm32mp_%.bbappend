FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-supports-stm32mp157c-odyssey.patch \
            "

